Properties of the parts of a building model (IFC2X3)

# File
Description: Temperaturregler für Feuchträume, Heizen/Kühlen, Wandmontage, Inneneinstellung, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: A201410, Temperaturregler für Feuchträume, Heizen/Kühlen, Wandmontage, Inneneinstellung
In: Raum
Description: Regelung und Überwachung von Temperaturen bestimmter Freiflächen, z. B. Auffahrten oder Feuchträume (Gewächshäuser, Hallen, Lager und Kellerräume, Garagen etc.).; Classification: EC010927 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: A201410; ModelLabel: PTR 40.000; GlobalTradeItemNumber: 4050528012531; ProductURL: https://alre.de/produkt_A201410
Pset_Specification - NominalLength: 0.169 m; NominalWidth: 0.096 m; NominalDepth: 0.056 m; NetWeight: 0.247
Pset_ALRE_ETIM_Properties - Montageart: Aufputz; Farbe: grau; Breite: 169; Höhe: 96; Tiefe: 56; RAL-Nummer: 7035; Anschluss: sonstige; Art der Spannungsversorgung: 230 V AC; Kontaktausführung: Wechsler (NO/NC); Messbereich: 20; Explosionsgeschützt: no; Schutzart (IP): IP65; Ausführung Aufnehmer/Fühler: Bimetall; Schutzart (NEMA): sonstige; Verdeckte Bedienung: yes; Max. Spannung der Kontakte: 230; Regelcharakteristik: P; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 1; Temperatur ablesbar: no; Max. Kontaktbelastung: 10; Differenzwert: 2; Sensor extern: no; Thermische Rückkopplung: parallel; Differenz verstellbar: no; Geeignet für Heizung: yes; Geeignet für Kühlen: yes; ETIM-Klasse: EC010927; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-A201410.pdf
